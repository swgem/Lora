# IAR project Lora.ewp, settings and files
configuration Lora (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RB ST STM32F103RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB; USE_STM32F1XX
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\BSP\sx1272mb2das; ..\BSP\sx1276mb1las; ..\BSP\sx1276mb1mas; ..\Middleware\Lora\Conf\Inc; ..\Middleware\Lora\Core; ..\Middleware\Lora\Phy; ..\Middleware\Lora\Utilities; ..\BSP\sx1276
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Lora.hex
  ILINK.IlinkOutputFile: Lora.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group BSP
    ../BSP/sx1276mb1las/: sx1276mb1las.c
    ../BSP/sx1276mb1mas/: sx1276mb1mas.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Middleware/Lora/Conf
    ../Middleware/Lora/Conf/Src/: hw_gpio_template.c hw_rtc_template.c hw_spi_template.c
  group Middleware/Lora/Core
    ../Middleware/Lora/Core/: lora-test.c lora.c
  group Middleware/Lora/Utilities
    ../Middleware/Lora/Utilities/: delay.c low_power_manager.c timeServer.c utilities.c
